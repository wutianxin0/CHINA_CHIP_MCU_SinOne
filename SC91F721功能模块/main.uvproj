# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC91F721 SC91Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(16000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./c/: PWM.C
