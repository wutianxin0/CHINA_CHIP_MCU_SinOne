# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC91F712 SC91Fxx Series
  cpu: IRAM(0-0x7F) IROM(0-0x7FF) CLOCK(16000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./c/: PWM.C
