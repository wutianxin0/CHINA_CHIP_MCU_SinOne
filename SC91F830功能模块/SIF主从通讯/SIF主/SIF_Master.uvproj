# Keil uVision project SIF_Master.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC91F73 SC91Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(16000000)
  output: SIF_Master +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./c/: Master_8_1.c Master_8_1_r_n.c
