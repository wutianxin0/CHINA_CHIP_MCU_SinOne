# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC91F72 SinOne Chip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(8000000)
  output: main +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main.c
